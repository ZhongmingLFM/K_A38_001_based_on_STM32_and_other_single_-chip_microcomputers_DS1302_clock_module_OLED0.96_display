# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: HEX +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User;..\User\Delay;..\User\Time0;..\User\OLED;..\User\Font;..\User\UART;..\User\DS1302
  link misc: REMOVEUNUSED
  group Source Group 1
    ../User/Delay/: Delay.c
    ../User/: main.c
    ../User/OLED/: OLED.C
    ../User/Font/: Font.c
    ../User/UART/: Uart.c
    ../User/DS1302/: DS1302.c
